inherit update-rc.d
inherit pkgconfig
inherit externalsrc
EXTERNALSRC = "/home/invite/w/src/esme-gpio-toggle"
EXTERNALSRC_BUILD = "/home/invite/w/src/esme-gpio-toggle"
